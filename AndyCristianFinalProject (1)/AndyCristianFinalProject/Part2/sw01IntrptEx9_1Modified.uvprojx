# Keil uVision project sw01IntrptEx9_1Modified.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C1233H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Example1
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: sw01IntrptEx9_1Modified.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
